# Keil uVision project stc89c516rd.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C58RD+ STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: stc89c516rd +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51 main.c rot.c test.c zk.c bmp.c uart.c delay.c button.c dht11.c ds1302.c lcd12864.c temps.c calendar.c jq8900.c game.c
  group New Group
    ./: rot.h test.h habit.h delay.h zk.h bmp.h button.h calendar.h lcd.h ds1302.h dht11.h temps.h
    ../project4/: uart.h jq8900.h
